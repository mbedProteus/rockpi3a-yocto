CORE_IMAGE_BASE_INSTALL += "packagegroup-core-full-cmdline"