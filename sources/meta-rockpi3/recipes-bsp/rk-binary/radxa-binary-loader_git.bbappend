
SRCREV = "db0c185306b5251c43ac2181fcab8ba2868d64bb"

LOADER_rk3568 = "bin/rk35/rk356x_spl_loader_ddr1056_v1.10.111.bin"
DDR_rk3568 = "bin/rk35/rk3568_ddr_1056MHz_v1.10.bin"
BL31_rk3568 = "bin/rk35/rk3568_bl31_v1.32.elf"
